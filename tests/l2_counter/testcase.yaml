## tests/l2_counter/testcase.yaml
```yaml
tests:
  homework.l2.counter:
    platform_allow: native_sim
    tags: homework
    timeout: 60
```
